<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>LASP_UHF_SDR_2_1_4b</value></param>
<param><key>author</key><value>LASP</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Copyright 2019 LASP, Univ. of Colorado</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>LASP - INSPIRE Ground Station</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Audio_volume</value></param>
<param><key>value</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>20</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BaudF</value></param>
<param><key>value</key><value>symbol_rate/9600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fdeviation</value></param>
<param><key>value</key><value>4800</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MIN_re_samp_rate</value></param>
<param><key>value</key><value>96000*BaudF</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Min_BaudF</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>label0</key><value>9600 bps</value></param>
<param><key>label1</key><value>19200 bps</value></param>
<param><key>label</key><value>MINXS2 Baud Rate</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>Rev_note_2_1_4a</value></param>
<param><key>value</key><value>'Swith Clock recovery from "polyphase clock sync" to M&amp;M \nSensitivity = pi*H_hindex/sps\nGain mu = 0.175'</value></param>
<param><key>gui_hint</key><value>tab@1:0,0</value></param>
<param><key>label</key><value>2.1.4a Changes</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>Rev_note_2_1_4b</value></param>
<param><key>value</key><value>'Fix the black stripe overtime'</value></param>
<param><key>gui_hint</key><value>tab@1:1,0</value></param>
<param><key>label</key><value>2.1.4b Changes</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_sample_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>corr_rx_freq</value></param>
<param><key>value</key><value>437.5e6</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>corr_tx_freq</value></param>
<param><key>value</key><value>437.5e6</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>9e3*Min_BaudF</value></param>
<param><key>label</key><value>Cutoff Freq</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>512*BaudF</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>h_index</value></param>
<param><key>value</key><value>2.0*Fdeviation/symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod</value></param>
<param><key>value</key><value>digital.cpmmod_bc(analog.cpm.GAUSSIAN, 0.5, re_samp_rate/symbol_rate, 4, 0.4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_preamble</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(int(re_samp_rate/symbol_rate*1.5),len(modulated_preamble_untrimmed)-int(re_samp_rate/symbol_rate*0.5))]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>data</key><value>preamble_nrz</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>mod</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>[0,0,0,0,0,1,0,1,0,1,0,1,0,0,0,0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_nrz</value></param>
<param><key>value</key><value>[i-1+256-i*255 for i in preamble]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>re_samp_rate</value></param>
<param><key>value</key><value>96000*BaudF</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>rev</value></param>
<param><key>value</key><value>'2.1.4b - 2018-12-21'</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>Rev </value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>437.5e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>34</value></param>
<param><key>gui_hint</key><value>3,0</value></param>
<param><key>label</key><value>rx_gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>system_clock/100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sensitivity</value></param>
<param><key>value</key><value>math.pi*h_index/sps</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_clock</value></param>
<param><key>value</key><value>30720000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>437.5e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>66</value></param>
<param><key>gui_hint</key><value>3,1</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>68</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>LO</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>100000+rx_freq-corr_rx_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>ais_invert</key>
<param><key>id</key><value>ais_invert_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>ais_invert</key>
<param><key>id</key><value>ais_invert_0_0</value></param>
</block>
<block>
<key>ais_square_and_fft_sync</key>
<param><key>id</key><value>ais_square_and_fft_sync_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftlen</key><value>fft_len</value></param>
<param><key>rate</key><value>MIN_re_samp_rate</value></param>
<param><key>sps</key><value>symbol_rate*Min_BaudF</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_samples</key><value>fft_len</value></param>
<param><key>reference</key><value>1.077</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>((symbol_rate/2.0)/math.pi)/(symbol_rate/4.0)</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>threshold</key><value>-80</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>audio_sample_rate</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/uhf-sdr/is1.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhengw-local/Raw_data_2020</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/uhf-sdr/IS-1/is1.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>Audio_volume</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_1</value></param>
<param><key>k</key><value>1</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>50000</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"TCP_CLIENT"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>50001</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"TCP_CLIENT"</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value>"time_est"</value></param>
<param><key>name</key><value>"corr_out"</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sps</key><value>re_samp_rate/symbol_rate</value></param>
<param><key>symbols</key><value>modulated_preamble</value></param>
<param><key>mark_delay</key><value>int(re_samp_rate/symbol_rate*0.5)+1</value></param>
<param><key>threshold_method</key><value>digital.corr_est_cc.THRESHOLD_ABSOLUTE</value></param>
<param><key>threshold</key><value>0.6</value></param>
</block>
<block>
<key>digital_cpmmod_bc</key>
<param><key>id</key><value>digital_cpmmod_bc_0</value></param>
<param><key>type</key><value>analog.cpm.LREC</value></param>
<param><key>mod_index</key><value>0.5</value></param>
<param><key>beta</key><value>0.4</value></param>
<param><key>L</key><value>4</value></param>
<param><key>samples_per_symbol</key><value>re_samp_rate/symbol_rate</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x00021</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x00021</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_gfsk_demod</key>
<param><key>id</key><value>digital_gfsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>10</value></param>
<param><key>sensitivity</key><value>sensitivity</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>500</value></param>
<param><key>min</key><value>4</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_0_0</value></param>
<param><key>max</key><value>500</value></param>
<param><key>min</key><value>32</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>-1,1</value></param>
</block>
<block>
<key>digital_msk_timing_recovery_cc</key>
<param><key>id</key><value>digital_msk_timing_recovery_cc_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>limit</key><value>0.01</value></param>
<param><key>gain</key><value>0.2</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>re_samp_rate/symbol_rate</value></param>
</block>
<block>
<key>digital_scrambler_bb</key>
<param><key>id</key><value>digital_scrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x00</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>re_samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,re_samp_rate,cutoff,1000,1)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>gpredict_port</key><value>4532</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>corr_rx_freq</key><value>corr_rx_freq</value></param>
<param><key>corr_tx_freq</key><value>corr_tx_freq</value></param>
<param><key>rx_freq</key><value>rx_freq</value></param>
<param><key>tx_freq</key><value>tx_freq</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>lithium_li_framer</key>
<param><key>id</key><value>lithium_li_framer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fend_length</key><value>5</value></param>
<param><key>frame_tag_name</key><value></value></param>
<param><key>preamble_length</key><value>80</value></param>
<param><key>fstart_length</key><value>30</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>6.5e3*BaudF</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>MIN_re_samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Copyright 2019 LASP</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Modulator has a two symbol delay</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>Telemetry socket</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>note</key><value>Command socket</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>1.0*MIN_re_samp_rate/samp_rate</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>1.0*samp_rate/re_samp_rate</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nfilts</key><value>1</value></param>
<param><key>rrate</key><value>1.2*audio_sample_rate/re_samp_rate</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_2</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>1.0*re_samp_rate/samp_rate</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1:0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Freq</value></param>
<param><key>name</key><value>"FSK Constellation"</value></param>
<param><key>size</key><value>612</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>xmax</key><value>1.1</value></param>
<param><key>xmin</key><value>-1.1</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-1.1</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>MIN_re_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0:0,1,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-30</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1:0,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Demod Signal</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>symbol_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>MIN_re_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0:0,0,1,1</value></param>
<param><key>int_max</key><value>-30</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>MIN_re_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0:0,0,1,1</value></param>
<param><key>int_max</key><value>-30</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>satellites_hdlc_framer</key>
<param><key>id</key><value>satellites_hdlc_framer_0</value></param>
<param><key>postamble_bytes</key><value>1</value></param>
<param><key>preamble_bytes</key><value>1</value></param>
</block>
<block>
<key>satellites_nrzi_encode</key>
<param><key>id</key><value>satellites_nrzi_encode_0</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>RF Signal</value></param>
<param><key>label1</key><value>Notes</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>tr_tr_switch_cc</key>
<param><key>id</key><value>tr_tr_switch_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>corr_tx_freq</key><value>corr_tx_freq</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>30000</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>30.72e6</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>30000</value></param>
<param><key>center_freq0</key><value>rx_freq+100000</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>system_clock</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>30000</value></param>
<param><key>center_freq0</key><value>rx_freq+100000</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>LO</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ais_invert_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ais_invert_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ais_invert_0_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ais_invert_0_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ais_square_and_fft_sync_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_feedforward_agc_cc_0</source_block_id><sink_block_id>digital_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_1</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>satellites_nrzi_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>lithium_li_framer_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>satellites_hdlc_framer_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>digital_msk_timing_recovery_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cpmmod_bc_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>ais_invert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0_0</source_block_id><sink_block_id>ais_invert_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_demod_0</source_block_id><sink_block_id>digital_descrambler_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>digital_cpmmod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_msk_timing_recovery_cc_0_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_msk_timing_recovery_cc_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_scrambler_bb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>digital_gfsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lithium_li_framer_0</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>ais_square_and_fft_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_2</source_block_id><sink_block_id>analog_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_2</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_hdlc_framer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_nrzi_encode_0</source_block_id><sink_block_id>digital_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
